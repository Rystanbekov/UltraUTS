# IAR project DIODES_CHECKER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_FULL_ASSERT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DIODES_CHECKER.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: DIODES_CHECKER.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: config.h init_periph.c init_periph.h main.c misc.c misc.h project_macro.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h system_stm32f10x.c system_stm32f10x.h
